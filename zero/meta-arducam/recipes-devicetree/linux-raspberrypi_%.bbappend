SRC_URI += "file://0001-dtoverlays-Add-arducam-pivariety-dts-file.patch"

FILESEXTRAPATHS:append := "${THISDIR}/files:"

PACKAGE_ARCH = "${MACHINE_ARCH}"
