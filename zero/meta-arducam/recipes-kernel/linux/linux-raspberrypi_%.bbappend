FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://arducam.cfg"
