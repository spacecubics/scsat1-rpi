FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
            file://0001-configs-Custom-configration-for-SC-Sat1.patch \
            "
